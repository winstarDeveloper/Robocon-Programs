#include <PID_v1.h>

//#include <PID_v1.h>
#include <Servo.h>
Servo myservo;

double Setpoint, Input, Output;
double aggKp = 4, aggKi = 0.2, aggKd = 1;
double consKp = 1, consKi = 0.05, consKd = 0.25;
PID myPID(&Input, &Output, &Setpoint, consKp, consKi, consKd, DIRECT);

int sensor = A1;
int new_angle=90;
int prev_angle=90;
int new_value=35;
int prev_value=35;
int interval=0;
const int junctionPulse = A2;

void setup() {
  myservo.attach(A0);
  Input = 33;
  Setpoint = 33;
  myPID.SetMode(AUTOMATIC);
  myPID.SetOutputLimits(-90, 90);
  for (int i = 0; i <= 90; i++)
  {
    myservo.write(i);
    // //Serial.println(i);
    delay(15);
  }

}

void loop() {
  int temp = analogRead(sensor);
  temp = map(temp, 0, 1023, 0, 255);
  new_value = ((temp * 0.02) / 4.5) * 70;
  Input = ceil (new_value);
  myPID.Compute();
  if (new_value >= 0  && new_value <= 70)
  {
    myPID.SetTunings(consKp, consKi, consKd);
  }
  else
  {
    myPID.SetTunings(aggKp, aggKi, aggKd);
  }
  myPID.Compute();
  new_angle = 90 - Output;
  interval=abs(new_angle-prev_angle);
  
  if (new_value >= 0  && new_value <= 70)
  { prev_value = new_value;
    myservo.write(new_angle);
    prev_angle = new_angle;
    delay(interval);
  }
  else if(new_value > 73)
  { if (prev_value==0)
    {new_angle= new_angle-97;
      myservo.write(new_angle);
      prev_angle = new_angle;
      delay(interval);
    }
    else if(prev_value>73)
    {myservo.write(new_angle);
    prev_angle = new_angle;
    delay(interval);
      }
    }
}

